Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\Projekt\20150210_CAD-objekt-Ove\Arbetsmapp\FMM\80635000\AutoCAD Architecture\80635000.ifc
Time: 2015-03-13T08:13:13
Author: - -
Organization: FM Mattsson
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 80635000
LongName: 80635000
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 80635000
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 80635000, BUILDINGELEMENTPROXY(1)
In: 80635000
Description: FMM Basin Mixer 9000E II with push down valve, Chrome
